# Keil uVision project Leviathan.uvprojx, settings and files
target Leviathan (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Leviathan +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,__FPU_PRESENT=1,__FPU_USED =1,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c misc: --c99
  c include: .\Libraries\CMSIS\Include;.\Libraries\CMSIS\ST\STM32F4xx\Include;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM4F;.\FreeRTOS\portable\MemMang;.\Applications;.\Driver;.\BSP;.\Math;.\Utility;.\Libraries\USB\STM32_USB_APP\USB_Device_Examples\VCP;.\Libraries\USB\STM32_USB_Device_Library\Core;.\Libraries\USB\STM32_USB_Device_Library\Class\cdc;.\Libraries\USB\STM32_USB_OTG_Driver;.\Libraries\FATFS\src;.\GUI;.\SEEGER\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ./Applications/: app_Init.c auto_auxiliary.c auto_infantry.c auto_sentry.c auto_tank.c auto_task.c auto_uav.c adrc.c cali.c cansend.c chassis.c config.c control.c clockcount.c differential_calculation.c deforming.c data_transmission.c gimbal.c imu.c judge.c local_id.c keyboard.c main.c parameter.c pid.c pneumatic.c processing.c rc.c power.c slave_sensor.c shoot.c supervisor.c tf_card_parameter.c supply.c type_robot.c vision.c vision_ukf.c wireless.c warning.c
  group driver
    ./Driver/: Driver_ADC.c Driver_Beep.c Driver_ClockCount.c Driver_DMMotor.c Driver_DTU.c Driver_Flash.c Driver_ITV.c Driver_Judge.c Driver_Motor_Dshot.c Driver_MPU6500.c Driver_Multi_Master.c Driver_RMDT7.c Driver_RMOLED.c Driver_RMMotor.c Driver_SDCard.c Driver_SK6812.c Driver_Slave_Sensor.c Driver_USBVCP.c Driver_VL53L0X.c Driver_Power.c Driver_powerContol.c Driver_Coder.c ISP_CAN.c ISP_EXIT.c ISP_SPI.c ISP_TIM.c ISP_USART.c
  group bsp
    ./BSP/: BSP_CAN.c BSP_DMA.c BSP_EXIT.c BSP_Flash.c BSP_GPIO.c BSP_PWM.c BSP_IIC_SW.c BSP_SPI_HW.c BSP_Timer.c BSP_USART.c BSP_WatchDog.c
  group lib
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_gpio.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_dma.c stm32f4xx_dac.c stm32f4xx_flash.c stm32f4xx_i2c.c stm32f4xx_it.c stm32f4xx_wwdg.c stm32f4xx_iwdg.c stm32f4xx_sdio.c
    ./FreeRTOS/: list.c event_groups.c croutine.c queue.c tasks.c timers.c
    ./FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./Libraries/USB/STM32_USB_OTG_Driver/: usb_core.c usb_dcd.c usb_dcd_int.c
    ./Libraries/USB/STM32_USB_Device_Library/Core/: usbd_core.c usbd_ioreq.c usbd_req.c
    ./Libraries/FATFS/src/: diskio.c ff.c
  group math
    ./Math/: algebra.c compass.c Matrix.c rotations.c srcdkf.c
    ./Applications/: ramp.c
  group util
    ./Utility/: Util.c cpu_utils.c
  group note
    ./: record.txt
  group CMSIS
    ./Libraries/CMSIS/Include/: arm_cortexM4lf_math.lib startup_stm32f427xx.s
    ./Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group GUI
    ./GUI/: UpperMonitor.c
  group SEGGER/RTT
    ./SEEGER/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
